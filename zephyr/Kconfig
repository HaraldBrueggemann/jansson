## zephyr/Kconfig
```kconfig
config LIB_JANSSON
    bool "Include Jansson JSON C++ library"
    default n
    depends on CPP && STD_CPP17 && REQUIRES_FULL_LIBCPP
```
